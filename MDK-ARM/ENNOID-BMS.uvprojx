# Keil uVision project ENNOID-BMS.uvprojx, settings and files
target ENNOID-BMS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ENNOID-BMS +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=ENNOID-BMS\@L.bin !L
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c misc: --C99
  c include: ../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;..\Drivers\HWDrivers\Inc;..\Drivers\HWDrivers\Src;..\Drivers\SWDrivers\Inc;..\Drivers\SWDrivers\Src;..\Modules\Inc;..\Modules\Src;..\Libraries\Inc;..\Libraries\Scr;..\Main;..\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x800
  memory RVCT5: ROM 0x8001800 size 0x15800
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Drivers/HALDriver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_spi.c stm32f3xx_hal_i2c.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_tim.c stm32f3xx_hal_flash.c stm32f3xx_hal_adc.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_iwdg.c
  group Drivers/HWDriver
    ../Drivers/HWDrivers/Src/: driverHWADC.c driverHWEEPROM.c driverHWI2C1.c driverHWI2C2.c driverHWPowerState.c driverHWSPI1.c driverHWStatus.c driverHWSwitches.c driverHWUART2.c
  group Drivers/SWDriver
    ../Drivers/SWDrivers/Src/: driverSWADC128D818.c driverSWCC1101.c driverSWEMC2305.c driverSWISL28022.c driverSWPCAL6416.c driverSWSHT21.c driverSWSSD1306.c driverSWStorageManager.c driverSWUART2.c driverSWLTC6804.c driverSWHTC1080.c
  group Config
    ../Config/: confparser.c confxml.c
  group Modules
    ../Modules/Src/: modCAN.c modCommands.c modConfig.c modDelay.c modDisplay.c modEffect.c modFlash.c modOperationalState.c modPowerElectronics.c modPowerState.c modStateOfCharge.c modTerminal.c modUART.c
  group Libraries
    ../Libraries/Src/: libBuffer.c libCRC.c libGLCDFont.c libGraphics.c libLogos.c libPacket.c libRingbuffer.c libMempools.c
  group Device
    ../Device/: startup_stm32f303xc.s stm32f3xx_hal_msp.c stm32f3xx_it.c
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
  group Main
    ../Main/: main.c
